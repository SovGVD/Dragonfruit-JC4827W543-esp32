#include "message.h"
#include <string.h>
#include <stdio.h>
#define PALM_W 160
#define PALM_H 160
#define PALM_STRIDE 20
/* ------------------------------------------------------------------ *
 *  Tiny 5x7 bitmap font for display_show_message().
 *
 *  Glyphs are stored as ASCII art so the source IS the proof — '#' is ink,
 *  anything else is blank. Indexed by (ASCII - ' '); undefined entries (and
 *  any NULL row) render blank, and lowercase is folded to uppercase before
 *  lookup. Only the characters we draw are defined; add more as needed.
 * ------------------------------------------------------------------ */
#define FONT_W 5
#define FONT_H 7

static const char *const font5x7['~' - ' ' + 1][FONT_H] = {
    /* ' ' is left undefined -> blank. */
    ['!' - ' '] = {"..#..","..#..","..#..","..#..","..#..",".....","..#.."},
    ['%' - ' '] = {"##..#","##.#.","...#.","..#..",".#...",".#.##","#..##"},
    ['(' - ' '] = {"..#..",".#...","#....","#....","#....",".#...","..#.."},
    [')' - ' '] = {"..#..","...#.","....#","....#","....#","...#.","..#.."},
    [',' - ' '] = {".....",".....",".....",".....","..##.","..##.",".#..."},
    ['-' - ' '] = {".....",".....",".....","#####",".....",".....","....."},
    ['.' - ' '] = {".....",".....",".....",".....",".....","..##.","..##."},
    ['/' - ' '] = {"....#","....#","...#.","..#..",".#...","#....","#...."},
    ['0' - ' '] = {".###.","#...#","#..##","#.#.#","##..#","#...#",".###."},
    ['1' - ' '] = {"..#..",".##..","..#..","..#..","..#..","..#..",".###."},
    ['2' - ' '] = {".###.","#...#","....#","...#.","..#..",".#...","#####"},
    ['3' - ' '] = {"#####","...#.","..#..","...#.","....#","#...#",".###."},
    ['4' - ' '] = {"...#.","..##.",".#.#.","#..#.","#####","...#.","...#."},
    ['5' - ' '] = {"#####","#....","####.","....#","....#","#...#",".###."},
    ['6' - ' '] = {"..##.",".#...","#....","####.","#...#","#...#",".###."},
    ['7' - ' '] = {"#####","....#","...#.","..#..",".#...",".#...",".#..."},
    ['8' - ' '] = {".###.","#...#","#...#",".###.","#...#","#...#",".###."},
    ['9' - ' '] = {".###.","#...#","#...#",".####","....#","...#.",".##.."},
    [':' - ' '] = {".....","..##.","..##.",".....","..##.","..##.","....."},
    ['?' - ' '] = {".###.","#...#","....#","...#.","..#..",".....","..#.."},
    ['A' - ' '] = {".###.","#...#","#...#","#####","#...#","#...#","#...#"},
    ['B' - ' '] = {"####.","#...#","#...#","####.","#...#","#...#","####."},
    ['C' - ' '] = {".###.","#...#","#....","#....","#....","#...#",".###."},
    ['D' - ' '] = {"####.","#...#","#...#","#...#","#...#","#...#","####."},
    ['E' - ' '] = {"#####","#....","#....","####.","#....","#....","#####"},
    ['F' - ' '] = {"#####","#....","#....","####.","#....","#....","#...."},
    ['G' - ' '] = {".###.","#...#","#....","#.###","#...#","#...#",".###."},
    ['H' - ' '] = {"#...#","#...#","#...#","#####","#...#","#...#","#...#"},
    ['I' - ' '] = {".###.","..#..","..#..","..#..","..#..","..#..",".###."},
    ['J' - ' '] = {"..###","...#.","...#.","...#.","#..#.","#..#.",".##.."},
    ['K' - ' '] = {"#...#","#..#.","#.#..","##...","#.#..","#..#.","#...#"},
    ['L' - ' '] = {"#....","#....","#....","#....","#....","#....","#####"},
    ['M' - ' '] = {"#...#","##.##","#.#.#","#.#.#","#...#","#...#","#...#"},
    ['N' - ' '] = {"#...#","##..#","#.#.#","#..##","#...#","#...#","#...#"},
    ['O' - ' '] = {".###.","#...#","#...#","#...#","#...#","#...#",".###."},
    ['P' - ' '] = {"####.","#...#","#...#","####.","#....","#....","#...."},
    ['Q' - ' '] = {".###.","#...#","#...#","#...#","#.#.#","#..#.",".##.#"},
    ['R' - ' '] = {"####.","#...#","#...#","####.","#.#..","#..#.","#...#"},
    ['S' - ' '] = {".####","#....","#....",".###.","....#","....#","####."},
    ['T' - ' '] = {"#####","..#..","..#..","..#..","..#..","..#..","..#.."},
    ['U' - ' '] = {"#...#","#...#","#...#","#...#","#...#","#...#",".###."},
    ['V' - ' '] = {"#...#","#...#","#...#","#...#","#...#",".#.#.","..#.."},
    ['W' - ' '] = {"#...#","#...#","#...#","#.#.#","#.#.#","#.#.#",".#.#."},
    ['X' - ' '] = {"#...#","#...#",".#.#.","..#..",".#.#.","#...#","#...#"},
    ['Y' - ' '] = {"#...#","#...#",".#.#.","..#..","..#..","..#..","..#.."},
    ['Z' - ' '] = {"#####","....#","...#.","..#..",".#...","#....","#####"},
    /* Punctuation for the Cybiko on-screen keyboard labels. */
    ['"' - ' '] = {".#.#.",".#.#.",".....",".....",".....",".....","....."},
    ['#' - ' '] = {".#.#.",".#.#.","#####",".#.#.","#####",".#.#.",".#.#."},
    ['$' - ' '] = {"..#..",".####","#.#..",".###.","..#.#","####.","..#.."},
    ['&' - ' '] = {".##..","#..#.","#.#..",".#...","#.#.#","#..#.",".##.#"},
    ['\'' - ' '] = {"..#..","..#..",".....",".....",".....",".....","....."},
    ['*' - ' '] = {".....","..#..","#.#.#",".###.","#.#.#","..#..","....."},
    ['+' - ' '] = {".....","..#..","..#..","#####","..#..","..#..","....."},
    [';' - ' '] = {".....","..##.","..##.",".....","..##.","..##.",".#..."},
    ['<' - ' '] = {"...#.","..#..",".#...","#....",".#...","..#..","...#."},
    ['=' - ' '] = {".....",".....","#####",".....","#####",".....","....."},
    ['>' - ' '] = {".#...","..#..","...#.","....#","...#.","..#..",".#..."},
    ['@' - ' '] = {".###.","#...#","#.###","#.#.#","#.###","#....",".###."},
    ['[' - ' '] = {".###.",".#...",".#...",".#...",".#...",".#...",".###."},
    ['\\' - ' '] = {"#....","#....",".#...","..#..","...#.","....#","....#"},
    [']' - ' '] = {".###.","...#.","...#.","...#.","...#.","...#.",".###."},
    ['^' - ' '] = {"..#..",".#.#.","#...#",".....",".....",".....","....."},
    ['_' - ' '] = {".....",".....",".....",".....",".....",".....","#####"},
    ['`' - ' '] = {".#...","..#..",".....",".....",".....",".....","....."},
    ['{' - ' '] = {"...##","..#..","..#..",".#...","..#..","..#..","...##"},
    ['|' - ' '] = {"..#..","..#..","..#..","..#..","..#..","..#..","..#.."},
    ['}' - ' '] = {"##...","..#..","..#..","...#.","..#..","..#..","##..."},
    ['~' - ' '] = {".....",".....",".#...","#.#.#","...#.",".....","....."},
};

int display_font_row(char c, int row)
{
    if (c >= 'a' && c <= 'z') c -= 32;
    if (c < ' ' || c > '~' || row < 0 || row >= FONT_H) return 0;
    const char *bits = font5x7[c - ' '][row];
    int mask = 0;
    for (int x = 0; bits && x < FONT_W && bits[x]; x++)
        if (bits[x] == '#') mask |= 0x10 >> x;
    return mask;
}

static void msg_set(uint8_t *fb, int x, int y)
{
    if (x < 0 || x >= PALM_W || y < 0 || y >= PALM_H) return;
    fb[y * PALM_STRIDE + (x >> 3)] |= (0x80 >> (x & 7));
}

static void msg_draw_char(uint8_t *fb, int x, int y, char c, int scale)
{
    if (c >= 'a' && c <= 'z') c -= 32;
    if (c < ' ' || c > '~') c = '?';
    const char *const *g = font5x7[c - ' '];
    for (int ry = 0; ry < FONT_H; ry++) {
        const char *row = g[ry];
        if (!row) continue;
        for (int rx = 0; rx < FONT_W && row[rx]; rx++)
            if (row[rx] == '#')
                for (int sy = 0; sy < scale; sy++)
                    for (int sx = 0; sx < scale; sx++)
                        msg_set(fb, x + rx * scale + sx, y + ry * scale + sy);
    }
}


void display_message_bitmap(const char *msg, uint8_t *msgfb)
{
    memset(msgfb, 0, 3200);
    const int scale  = 2;
    const int adv    = (FONT_W + 1) * scale;   /* per-char advance incl. 1px gap */
    const int line_h = (FONT_H + 2) * scale;   /* per-line advance incl. 2px gap */

    int nlines = 1;
    for (const char *p = msg; *p; p++) if (*p == '\n') nlines++;

    int total_h = nlines * line_h - 2 * scale;
    int y = (PALM_H - total_h) / 2;
    if (y < 0) y = 0;

    const char *p = msg;
    while (1) {
        const char *e = p;
        while (*e && *e != '\n') e++;
        int len = (int)(e - p);
        int w = len > 0 ? len * adv - scale : 0;   /* trim trailing gap */
        int x = (PALM_W - w) / 2;
        if (x < 0) x = 0;
        for (const char *c = p; c < e; c++) {
            msg_draw_char(msgfb, x, y, *c, scale);
            x += adv;
        }
        y += line_h;
        if (*e == '\0') break;
        p = e + 1;
    }

}

void display_progress_bitmap(const char *title, const char *phase, int percent, uint8_t *fb)
{
    char text[96];
    if (percent > 100) percent = 100;
    if (percent >= 0)
        snprintf(text, sizeof(text), "%.13s\n%.13s\n%d%%\n\nKEEP POWER ON", title, phase, percent);
    else
        snprintf(text, sizeof(text), "%.13s\n%.13s\nPLEASE WAIT\n\nKEEP POWER ON", title, phase);
    display_message_bitmap(text, fb);
    const int left = 12, right = 147, top = 136, bottom = 145;
    for (int x = left; x <= right; x++) { msg_set(fb, x, top); msg_set(fb, x, bottom); }
    for (int y = top; y <= bottom; y++) { msg_set(fb, left, y); msg_set(fb, right, y); }
    int filled = percent >= 0 ? (right - left - 1) * percent / 100 : 0;
    for (int y = top + 1; y < bottom; y++)
        for (int x = left + 1; x <= left + filled; x++) msg_set(fb, x, y);
}
